## esp32/sdkconfig.defaults
```kconfig
CONFIG_ESPTOOLPY_BAUD_921600B=y

CONFIG_FREERTOS_GENERATE_RUN_TIME_STATS=y
CONFIG_FREERTOS_GENERATE_REAL_TIME_STATS=y
```
